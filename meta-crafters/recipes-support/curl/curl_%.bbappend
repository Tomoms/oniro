FILESEXTRAPATHS:prepend := "${THISDIR}/curl:"
SRC_URI += " \
    file://cve-2022-42915.patch \
    file://cve-2022-42916.patch \
    "
