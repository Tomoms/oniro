FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += " file://cve-2022-43680.patch "
