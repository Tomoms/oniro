FILESEXTRAPATHS:prepend := "${THISDIR}/libpam:"
SRC_URI += " file://cve-2022-28321.patch "
